# Keil uVision project RTC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: RTC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C.c I2C.h Includes.h LCD.c Main.c delay.c keypad.c
