# Keil uVision project LM35_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: LM35_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc804.c delay.c LM35_LCD.c lcd.c
